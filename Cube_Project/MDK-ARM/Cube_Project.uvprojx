# Keil uVision project Cube_Project.uvprojx, settings and files
target Cube_Project (6120000::V6.12::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Cube_Project +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,_MSC_VER,VSF_UTILITIES_REQ___CMSIS_HEADER_FILE__FROM_USR=\"stm32f1xx_hal.h\"
  c misc: -Omax -fms-extensions -Wno-empty-body -Wno-microsoft-anon-tag -Wno-nonportable-include-path -Wno-tautological-constant-out-of-range-compare
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\..\Vsf\release\kernel\beta\vsf;..\..\Vsf\release\kernel\beta\example\usrapp\template\app_cfg;..\User_App\check_string;..\User_App\check_use_peek;..\User_App\critical_sector;..\User_App\event;..\User_App\key;..\User_App\led;..\User_App\mailbox;..\User_App\print_string;..\User_App\queue;..\User_App\msg_map;..\..\Vsf\release\kernel\beta\vsf\utilities\3rd-party\PLOOC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group User_App
    ../User_App/queue/: queue.c
    ../User_App/event/: event.c
    ../User_App/critical_sector/: critical_sector.c
    ../User_App/key/: key.c
    ../User_App/led/: led.c
    ../User_App/mailbox/: mailbox.c
    ../User_App/: app_cfg.h
    ../User_App/check_string/: check_string.c
    ../User_App/t_pool/: t_pool.h
    ../User_App/print_string/: print_string.c
    ../User_App/msg_map/: msg_map.c
    ../User_App/check_use_peek/: check_use_peek.c
    ../User_App/console/: console.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Vsf/Retarget
    ../../Vsf/release/kernel/beta/vsf/utilities/compiler/arm/: vsf_stdio_lib.a
    ../Src/: user_retarget.c
  group Plooc
    ../../Vsf/release/kernel/beta/vsf/utilities/3rd-party/PLOOC/: plooc.h plooc_class.h plooc_class_simple.h plooc_class_strict.h
software components: CMSIS:CORE 5.2.0
